XTF_TEST_CASES_POPULATE = "pv livepatch-priv-check argo"
XTF_TEST_CASES_REQUIRE = "test-pv64-argo"
