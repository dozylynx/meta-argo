require xen-hypervisor-argo.inc

FILESEXTRAPATHS:prepend := "${THISDIR}/xen:"
